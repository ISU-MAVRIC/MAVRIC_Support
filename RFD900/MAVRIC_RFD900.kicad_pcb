# Repository ISU-MAVRIC/MAVRIC_Support

File README.md:

MAVRIC_Support
==============

Support hardware

## KiCad design RFD900/MAVRIC_RFD900.kicad_pcb

Parts:
C1, C2, C3: 22uF; Voltage 16V
C4: C
J1: HOST
J2: RFD900
L1: L
R1: 10k
R2, R3, R4: R
U1: AOZ1031

Connections:
+5V: C1.1, C2.1, J2.4, J2.5, J2.6, L1.2, R2.2
+BATT: C3.1, J1.4, J1.5, R1.1, U1.2 (VIn)
/Lx: L1.1, U1.7 (L), U1.8 (L)
/RxOut: J1.3, J2.9
/TxIn: J1.1, J2.7
GND: C1.2, C2.2, C3.2, C4.2, J1.2, J1.6, J1.7, J1.8, J2.1, J2.2, J2.16, R4.1, U1.1 (PGnd), U1.3 (AGnd)
unnamed: R1.2, U1.6 (En)
unnamed: R3.2, U1.5 (Comp)
unnamed: C4.1, R3.1
unnamed: R2.1, R4.2, U1.4 (FB)

Board: 2 copper layers, 12 parts (0 on the bottom side), 10 nets.

## Commit log

2013-09-13 Add rough RFD900 board
